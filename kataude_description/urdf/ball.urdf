Commit message: souwan added

File: kataude_description/urdf/ball.urdf (robot description, URDF)
Before this commit: robot ball_robot, 1 links, 0 joints
Links:
- link ball_link: geometry collision sphere radius=100; visual sphere radius=100
